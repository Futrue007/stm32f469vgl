# Keil uVision project Project.uvprojx, settings and files
target stm32f469_display (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F469NIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000-0x2004FFFF) IRAM2(0x10000000-0x2000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: stm32f469_dispaly +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F469xx,LV_CONF_INCLUDE_SIMPLE
  c misc: --C99 --gnu
  c include: ..\Inc;..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\Drivers\CMSIS\Include;..\Drivers\STM32F4xx_HAL_Driver\Inc;..\Drivers\BSP\STM32469I-Discovery;..\Drivers\BSP\Components\Common;..\Utilities\Log;..\Utilities\Fonts;..\Utilities\CPU;..\GUI\lvgl;..\GUI\lv_examples;..\GUI\lv_examples\lv_apps\demo;..\GUI\lvgl\lv_core;..\GUI\lvgl\lv_draw;..\GUI\lvgl\lv_fonts;..\GUI\lvgl\lv_hal;..\GUI\lvgl\lv_misc;..\GUI\lvgl\lv_objx;..\GUI\lvgl\lv_themes;..\GUI\lv_examples\lv_tests\lv_test_theme
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x50000
  scatter file: .\stm32f469_display\LCD_DSI_ImagesSlider.sct
  link misc: --diag_suppress=L6329
  group Example/MDK-ARM
    ./: startup_stm32f469xx.s
  group Example/User
    ../Src/: stm32f4xx_hal_msp.c main.c stm32f4xx_it.c bsp_uart.c
  group Drivers/BSP/STM32469I_EVAL
    ../Drivers/BSP/STM32469I-Discovery/: stm32469i_discovery_lcd.c stm32469i_discovery_qspi.c stm32469i_discovery_sdram.c stm32469i_discovery_ts.c stm32469i_discovery.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_sram.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_rcc.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_uart.c stm32f4xx_ll_fmc.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_dsi.c stm32f4xx_hal_sdram.c stm32f4xx_hal_i2c.c stm32f4xx_hal_pwr.c stm32f4xx_hal_cortex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr_ex.c
  group Drivers/BSP/Components
    ../Drivers/BSP/Components/otm8009a/: otm8009a.c
    ../Drivers/BSP/Components/ft6x06/: ft6x06.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group lvgl_hal
    ../GUI/lvgl/lv_hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group lvgl_misc
    ../GUI/lvgl/lv_misc/: lv_anim.c lv_mem.c lv_area.c lv_circ.c lv_color.c lv_font.c lv_fs.c lv_ll.c lv_log.c lv_math.c lv_task.c lv_templ.c lv_txt.c lv_ufs.c
  group lvgl_core
    ../GUI/lvgl/lv_core/: lv_group.c lv_indev.c lv_obj.c lv_refr.c lv_style.c lv_vdb.c
  group lvgl_draw
    ../GUI/lvgl/lv_draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_rbasic.c lv_draw_rect.c lv_draw_triangle.c lv_draw_vbasic.c
  group lvgl_objx
    ../GUI/lvgl/lv_objx/: lv_arc.c lv_bar.c lv_btn.c lv_btnm.c lv_calendar.c lv_cb.c lv_chart.c lv_cont.c lv_ddlist.c lv_gauge.c lv_img.c lv_imgbtn.c lv_kb.c lv_label.c lv_led.c lv_line.c lv_list.c lv_lmeter.c lv_mbox.c lv_objx_templ.c lv_page.c lv_preload.c lv_roller.c lv_slider.c lv_sw.c lv_ta.c lv_tabview.c lv_win.c
  group lvgl_themes
    ../GUI/lvgl/lv_themes/: lv_theme.c lv_theme_alien.c lv_theme_default.c lv_theme_material.c lv_theme_mono.c lv_theme_nemo.c lv_theme_night.c lv_theme_templ.c lv_theme_zen.c
  group lvgl_examples
    ../GUI/lv_examples/lv_apps/demo/: demo.c img_bubble_pattern.c
    ../GUI/lv_examples/lv_tests/lv_test_theme/: lv_test_theme.c
  group lvgl_font
    ../GUI/lvgl/lv_fonts/: lv_font_builtin.c lv_font_dejavu_10.c lv_font_dejavu_10_cyrillic.c lv_font_dejavu_10_latin_sup.c lv_font_dejavu_20.c lv_font_dejavu_20_cyrillic.c lv_font_dejavu_20_latin_sup.c lv_font_dejavu_30.c lv_font_dejavu_30_cyrillic.c lv_font_dejavu_30_latin_sup.c lv_font_dejavu_40.c lv_font_dejavu_40_cyrillic.c lv_font_dejavu_40_latin_sup.c lv_font_monospace_8.c lv_font_symbol_10.c lv_font_symbol_20.c lv_font_symbol_30.c lv_font_symbol_40.c
software components: CMSIS:CORE 4.1.0
